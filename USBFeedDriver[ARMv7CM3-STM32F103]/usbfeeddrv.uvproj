# Keil uVision project usbfeeddrv.uvproj, settings and files
target STM32F103RBT6 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: usbfeeddrv +hex
  c flags: Optim=3
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s init.c
  group Source
    ./: main.c rtc.c iwdt.c usbfeed.c
